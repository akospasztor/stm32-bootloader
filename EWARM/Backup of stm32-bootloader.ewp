# IAR project Backup of stm32-bootloader.ewp, settings and files
configuration L476 (ARM, debug)
  General.OGChipSelectEditMenu: STM32L476VG ST STM32L476VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L476xx
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/CMSIS/Include; ../Drivers/CMSIS/Device/ST/STM32L4xx/Include; ../Drivers/STM32L4xx_HAL_Driver/Inc; ../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy; ../Middlewares/Third_Party/FatFs/src; ../Middlewares/Third_Party/FatFs/src/driver; ../Middlewares/Third_Party/FatFs/src/option
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: stm32-bootloader.bin
  ILINK.IlinkOutputFile: stm32-bootloader.out
  ILINK.IlinkIcfFile: stm32l476xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration L496 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32L496VG ST STM32L496VG
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L496xx
  ILINK.IlinkIcfFile: stm32l496xx_flash.icf
  group Application/EWARM
    ./: startup_stm32l476xx.s startup_stm32l496xx.s stm32l476xx_flash.icf stm32l496xx_flash.icf
  group Application/Inc
    ../Inc/: bootloader.h bsp_driver_sd.h fatfs.h ffconf.h main.h stm32l4xx_hal_conf.h stm32l4xx_it.h
  group Application/Src
    ../Src/: bootloader.c bsp_driver_sd.c fatfs.c main.c stm32l4xx_it.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Drivers/STM32L4xx_HAL_Driver
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_cortex.c stm32l4xx_hal_crc.c stm32l4xx_hal_crc_ex.c stm32l4xx_hal_dma.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_sd.c stm32l4xx_ll_sdmmc.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
  group Middlewares/FatFs/driver
    ../Middlewares/Third_Party/FatFs/src/driver/: sd_diskio.c
  group Middlewares/FatFs/option
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c
