# IAR project stm32-bootloader.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32L496AG ST STM32L496AG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L496xx
  ICCARM.CCIncludePath2: ../include; ../../../lib/stm32-bootloader; ../../../lib/fatfs; ../../../Drivers/CMSIS/Include; ../../../Drivers/CMSIS/Device/ST/STM32L4xx/Include; ../../../Drivers/STM32L4xx_HAL_Driver/Inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: app-demo.bin
  ILINK.IlinkOutputFile: stm32-bootloader.out
  ILINK.IlinkIcfFile: stm32l496xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32l496xx.s stm32l496xx_flash.icf
  group Application/Include
    ../include/: main.h stm32l4xx_hal_conf.h stm32l4xx_it.h
  group Application/Source
    ../source/: main.c stm32l4xx_it.c system_stm32l4xx.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_cortex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c
