# IAR project stm32-bootloader.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32L496VG ST STM32L496VG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L496xx
  ICCARM.CCIncludePath2: ../include; ../../../lib/stm32-bootloader; ../../../lib/fatfs; ../../../Drivers/CMSIS/Include; ../../../Drivers/CMSIS/Device/ST/STM32L4xx/Include; ../../../Drivers/STM32L4xx_HAL_Driver/Inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: stm32-bootloader.bin
  ILINK.IlinkOutputFile: stm32-bootloader.out
  ILINK.IlinkIcfFile: stm32l496xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration L496 (ARM, debug)
  as the first configuration, except:
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/CMSIS/Device/ST/STM32L4xx/Include; ../Drivers/STM32L4xx_HAL_Driver/Inc; ../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy; ../Middlewares/Third_Party/FatFs/src; ../Middlewares/Third_Party/FatFs/src/driver; ../Middlewares/Third_Party/FatFs/src/option
configuration L476 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32L476VG ST STM32L476VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L476xx
  ICCARM.CCIncludePath2: as above
  ILINK.IlinkIcfFile: stm32l476xx_flash.icf
  group Application/EWARM
    ./: startup_stm32l496xx.s stm32l496xx_flash.icf
  group Application/Include
    ../include/: bsp_driver_sd.h fatfs.h ffconf.h main.h sd_diskio.h stm32l4xx_hal_conf.h stm32l4xx_it.h
  group Application/Source
    ../source/: bsp_driver_sd.c fatfs.c main.c sd_diskio.c stm32l4xx_it.c system_stm32l4xx.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_cortex.c stm32l4xx_hal_crc.c stm32l4xx_hal_crc_ex.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_sd.c stm32l4xx_hal_sd_ex.c stm32l4xx_ll_sdmmc.c
  group Lib/Bootloader
    ../../../lib/stm32-bootloader/: bootloader.c bootloader.h
  group Lib/FatFs
    ../../../lib/fatfs/: diskio.c ff.c ff_gen_drv.c
  group Lib/FatFs/option
    ../../../lib/fatfs/option/: unicode.c
